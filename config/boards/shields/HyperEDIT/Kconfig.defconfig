## config/boards/shields/HyperEDIT/Kconfig.defconfig
```kconfig
if SHIELD_HYPEREDIT

config ZMK_KEYBOARD_NAME
	default "HyperEDIT"

CONFIG_ZMK_POINTING=y
	
endif
```
